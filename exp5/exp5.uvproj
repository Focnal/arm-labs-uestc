# Keil uVision project exp5.uvproj, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: exp5
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  asm define: __EVAL
  memory RVCT1: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x40000000 size 0x1000
  link misc: --first s3c2440.o(RESET)
  group Source Group 1
    ./: S3C2440.s test.c
